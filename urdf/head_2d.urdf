Commit message: added collision to the base link

File: urdf/head_2d.urdf (robot description, URDF)
Before this commit: robot farm, 6 links, 5 joints
Links:
- link base_link: geometry collision cylinder length=0.10 radius=0.185; visual cylinder length=0.015 radius=0.185
